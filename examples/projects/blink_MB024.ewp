# IAR project blink_MB024.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373NT MindMotion MM32L373NT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM3N1; __MB024; OVERTIME=0; CLOCK=8000000; __USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: ..\app\inc; ..\bsp\inc; ..\lib\HAL_lib\inc; ..\lib\startup\inc; ..\lib\FreeRTOS\include; ..\lib\FreeRTOS\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\lib\FreeRTOS\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: blink.srec
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: main.c
  group bsp
    ../bsp/: bsp_key.c bsp_led.c
  group lib/FreeRTOS
    ../lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../lib/FreeRTOS/portable/IAR/ARM_CM3/: port.c
  group lib/FreeRTOS/port
    ../lib/FreeRTOS/portable/MemMang/: heap_2.c
    ../lib/FreeRTOS/portable/IAR/ARM_CM3/: portasm.s
  group lib/HAL_lib
    ../lib/HAL_lib/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../lib/startup/: startup_mm32.c system_mm32.c
